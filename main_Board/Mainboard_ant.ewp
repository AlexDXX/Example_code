# IAR project Mainboard_ant.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_HD
  ICCARM.CCIncludePath2: $PROJ_DIR$; FreeRTOS/sources; FreeRTOS/include; CMSIS/CM3/DeviceSupport/ST/STM32F10x; STM32F10x_StdPeriph_Driver/src; STM32F10x_StdPeriph_Driver/inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Mainboard_ant.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: LIS3MDL.c main.c MPU6500.c startup_stm32f10x_hd.s system_stm32f10x.c
